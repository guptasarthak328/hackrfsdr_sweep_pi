options:
  parameters:
    generate_options: no_gui
    id: feb23
    output_language: python
    run_options: run
    title: HackRF Sweep Pi
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: /home/pi/Desktop/hackrf_sdr/pi_test
    max_seg_size: vec_len
    rel_rate: '1'
    samp_rate: samp_rate
    type: float
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/vec_len
    type: complex
    vlen: vec_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: complex
    share_type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: vec_len
    type: complex
    value: pmt.intern("TEST")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tag_share_0, '0', blocks_throttle_0, '0']
- [blocks_tags_strobe_0, '0', blocks_tag_share_0, '1']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', blocks_tag_share_0, '0']

metadata:
  file_format: 1
